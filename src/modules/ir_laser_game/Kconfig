## src/modules/ir_laser_game/Kconfig
```kconfig
menuconfig MODULES_IR_LASER_GAME
	bool "ir_laser_game"
	default n
	---help---
		Launch laser game process
```
